# Keil uVision project MSS_F103.uvprojx, settings and files
target MSS_F103 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: atk_f103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\..\Drivers;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F1xx\Include;..\..\Drivers\STM32F1xx_HAL_Driver\Inc;..\..\Middlewares;..\..\User;..\..\User\include;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\Drivers\FREE_MODBUS\include;..\..\Drivers\FREE_MODBUS\rtu;..\..\Test
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group User
    ../../User/: main.c stm32f1xx_it.c led.c dataCollect.c control.c UpdateState.c SystemSafety.c config.c pwm3TIM.c pwmSoft.c
    ../../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group User/include
    ../../User/include/: FreeRTOSConfig.h globalE.h stm32f1xx_hal_conf.h stm32f1xx_it.h SystemSafety.h taskConfig.h UpdateState.h control.h dataCollect.h led.h config.h pwm3TIM.h pwmSoft.h
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_spi.c
  group Drivers/BSP
    ../../Drivers/BSP/GPIO/: gpio.c gpio.h
    ../../Drivers/BSP/TIM/: tim.c tim.h
    ../../Drivers/BSP/ADC/: adc.c adc.h
    ../../Drivers/BSP/UART/: uart.c uart.h
    ../../Drivers/BSP/SPI/: spi.c spi.h
    ../../Drivers/BSP/FLASH/INTERNAL/: flash.c flash.h
    ../../Drivers/BSP/FLASH/W25Q64/: w25q64.c w25q64.h
  group Test
    ../../Test/: unity.c unity_internals.h unity_around.c
  group Drivers/FREE_MODBUS/port
    ../../Drivers/FREE_MODBUS/port/: mb.c mb_reg.c portevent.c portserial.c porttimer.c
  group Drivers/FREE_MODBUS/rtu
    ../../Drivers/FREE_MODBUS/rtu/: mbcrc.c mbrtu.c
  group Drivers/FREE_MODBUS/functions
    ../../Drivers/FREE_MODBUS/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Middlewares/FreeRTOS_CORE
    ../../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
